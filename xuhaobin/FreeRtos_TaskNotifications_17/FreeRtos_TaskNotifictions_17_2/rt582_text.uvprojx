# Keil uVision project rt582_text.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rt582_text +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\config;.\Library\CMSIS\Include;.\Library\RT58x\Include;.\Library\RT58x\Peripheral\Include;.\Library\RT58x\PHY\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\FreeRTOS\Source\include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
    ./config/: project_config.h
  group startup
    ./Library/RT58x/Device/: system_cm3_mcu.c
    ./Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ./Library/RT58x/Peripheral/: flashctl.c retarget_drv_keil.c timer.c uart_drv.c mp_sector.c lpm.c dma.c gpio.c sysctrl.c sysfun.c
    ./: lib_rf_mcu.lib
  group FREERTOS_CORE
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/include/: FreeRTOSConfig.h
  group FREERTOS_PORTABLE
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.1.2
