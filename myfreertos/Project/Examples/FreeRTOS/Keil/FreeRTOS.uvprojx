# Keil uVision project FreeRTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOS +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\config;..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\FreeRTOS;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\Library\RT58x\include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../: main.c key_handler.c key_handler.h semaphore_handler.c semaphore_handler.h eventgrp_handler.c eventgrp_handler.h pwm_control.c pwm_control.h tasks_and_timers.c tasks_and_timers.h queue_task.c queue_task.h task_config.h
    ../config/: project_config.h
  group Startup
    ../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../Library/RT58x/Peripheral/: gpio.c sysctrl.c retarget_drv_keil.c sysfun.c timer.c uart_drv.c flashctl.c dma.c lpm.c mp_sector.c pwm.c
    ../../../../Middleware/Prebuild/: lib_rf_mcu.lib
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c event_groups.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../: FreeRTOSConfig.h
software components: CMSIS:CORE 5.0.1
